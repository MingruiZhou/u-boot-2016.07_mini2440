## configs/mini2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_MINI2440=y
CONFIG_BOOTDELAY=5
CONFIG_SYS_PROMPT="MINI2440 # "
```
